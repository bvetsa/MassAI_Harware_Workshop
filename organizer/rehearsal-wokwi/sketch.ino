// Generated from the four firmware source files.
#include <Arduino.h>

#include <stddef.h>
#include <stdint.h>
#include <string.h>
#include <math.h>

constexpr size_t kInputs = 64;
constexpr float kTolerance = 0.00001f;
static_assert(sizeof(float) == 4, "Model Golf requires IEEE binary32 floats");

struct DemoCase {
  const char *id;
  int annotation;
  float pythonLogit;
  float samples[kInputs];
};

inline float readFloat(const uint8_t *bytes) {
  uint32_t bits = uint32_t(bytes[0]) | (uint32_t(bytes[1]) << 8) |
                  (uint32_t(bytes[2]) << 16) | (uint32_t(bytes[3]) << 24);
  float value;
  memcpy(&value, &bits, sizeof(value));
  return value;
}

inline float readWeight(const uint8_t *bytes, bool int8, float scale) {
  if (!int8) return readFloat(bytes);
  const int signedValue = bytes[0] < 128 ? bytes[0] : int(bytes[0]) - 256;
  return float(signedValue) * scale;
}

inline float multiplyAdd(float sum, float value, float weight) {
  // Round the product before adding, as in the Python reference.
  volatile float product = value * weight;
  return sum + product;
}

inline float predict(const uint8_t *model, size_t bytes, const float *input) {
  constexpr size_t header = 6;
  if (bytes < header || memcmp(model, "MGF1", 4) != 0) return NAN;
  const size_t width = model[4];
  const bool int8 = model[5] == 8;
  if (width != 4 && width != 8 && width != 16 && width != 24) return NAN;
  if (!int8 && model[5] != 32) return NAN;
  const size_t stride = int8 ? 1 : 4;
  const size_t scaleBytes = int8 ? 8 : 0;
  if (bytes != header + scaleBytes + (kInputs + 1) * width * stride + 4 * (width + 1)) return NAN;

  const float s1 = int8 ? readFloat(model + header) : 1.0f;
  const float s2 = int8 ? readFloat(model + header + 4) : 1.0f;
  const uint8_t *w1 = model + header + scaleBytes;
  const uint8_t *b1 = w1 + width * kInputs * stride;
  const uint8_t *w2 = b1 + width * 4;
  float logit = readFloat(w2 + width * stride);
  for (size_t j = 0; j < width; ++j) {
    float hidden = readFloat(b1 + j * 4);
    for (size_t i = 0; i < kInputs; ++i) {
      const float weight = readWeight(w1 + (j * kInputs + i) * stride, int8, s1);
      hidden = multiplyAdd(hidden, input[i], weight);
    }
    const float outputWeight = readWeight(w2 + j * stride, int8, s2);
    logit = multiplyAdd(logit, hidden > 0.0f ? hidden : 0.0f, outputWeight);
  }
  return logit;
}

inline bool matchesPython(float z, float reference) {
  return isfinite(z) && fabsf(z - reference) <= kTolerance && (z >= 0) == (reference >= 0);
}

#include <stdint.h>

constexpr char kModelSha256[] = "716f7019db703fc32144398d29dc7488b8acee88fd86a7ef741ea6b1039fcdd7";
constexpr uint8_t kModel[] = {
  0x4d, 0x47, 0x46, 0x31, 0x08, 0x08, 0x4f, 0x14, 0x49, 0x3c, 0x20, 0x96, 0x7b, 0x3c, 0x3b, 0x06,
  0xfc, 0xed, 0xdb, 0xc6, 0x88, 0x89, 0x9b, 0xae, 0xaf, 0xee, 0x10, 0x37, 0x0f, 0xf4, 0x0b, 0x4f,
  0x40, 0x22, 0xf3, 0xf8, 0x27, 0x22, 0x36, 0x00, 0xf2, 0xf3, 0xdf, 0xe5, 0xf8, 0x0d, 0xed, 0x07,
  0x26, 0x0c, 0x06, 0xf1, 0x1c, 0x04, 0x07, 0xd7, 0xac, 0xdf, 0xaa, 0xc7, 0xd0, 0xbb, 0xde, 0xf8,
  0x08, 0x0f, 0xf9, 0xf8, 0x0a, 0x0c, 0xdd, 0xdf, 0xf5, 0xf2, 0xdf, 0xe7, 0xea, 0xd6, 0xe9, 0x06,
  0xfa, 0xfe, 0x18, 0x24, 0x38, 0x3b, 0x59, 0x4a, 0x42, 0x3d, 0x48, 0x32, 0xdf, 0xdc, 0xe7, 0x0b,
  0xec, 0xdc, 0xf8, 0xef, 0xef, 0xe8, 0xe2, 0xcf, 0xd5, 0xd1, 0xd2, 0xcd, 0xe1, 0xf9, 0x0b, 0x01,
  0x0a, 0x07, 0x02, 0x06, 0x04, 0x0f, 0x1d, 0x0b, 0x03, 0x2a, 0x10, 0x24, 0x4f, 0x51, 0x46, 0x3f,
  0x07, 0x38, 0x14, 0x2c, 0x1b, 0x0b, 0x05, 0x14, 0x27, 0xfe, 0xfd, 0x2a, 0x25, 0xfc, 0x03, 0xff,
  0xf7, 0xd8, 0xc9, 0xdc, 0xc5, 0xb9, 0xb7, 0xe1, 0xdf, 0xf9, 0x1d, 0x2c, 0x12, 0x0c, 0x01, 0x42,
  0x22, 0x01, 0x08, 0xe7, 0x24, 0x0c, 0xf6, 0x04, 0x03, 0xff, 0xfb, 0x10, 0x41, 0x19, 0x26, 0x11,
  0x02, 0x00, 0x0a, 0xfd, 0xf2, 0xf4, 0xf6, 0xe8, 0xd8, 0xee, 0xd1, 0xd7, 0xfd, 0xd0, 0xfd, 0xea,
  0x12, 0x03, 0xff, 0x00, 0x05, 0x16, 0xe5, 0xf1, 0xda, 0xd8, 0xc6, 0xcc, 0xe5, 0xf1, 0x0f, 0x01,
  0x1f, 0x09, 0x0d, 0x0a, 0x07, 0x2a, 0x07, 0x33, 0x30, 0x41, 0x52, 0x4c, 0xef, 0xdf, 0xe8, 0x3b,
  0x3c, 0x02, 0x09, 0xef, 0x0c, 0xdc, 0xc1, 0xa3, 0x83, 0x88, 0x81, 0xcd, 0xf6, 0x0c, 0x1b, 0x2f,
  0x28, 0x25, 0x1f, 0x2d, 0x25, 0x0f, 0x14, 0x0e, 0xfb, 0xfe, 0xf8, 0xee, 0xf7, 0x05, 0xee, 0x0c,
  0x01, 0x15, 0x1f, 0x25, 0x0f, 0x1c, 0x13, 0x26, 0x23, 0x2e, 0x23, 0x14, 0x12, 0x10, 0x87, 0xa2,
  0xa4, 0xe9, 0xf1, 0xc7, 0x27, 0x36, 0x28, 0xf3, 0xee, 0xcd, 0xc8, 0xc0, 0xec, 0x18, 0x1d, 0xe6,
  0xc9, 0x12, 0x2e, 0x31, 0x26, 0xde, 0xb5, 0x02, 0x1a, 0x39, 0x26, 0x19, 0x24, 0x02, 0xf3, 0xd3,
  0xe1, 0xde, 0xfb, 0xec, 0x0e, 0xeb, 0xf5, 0x0d, 0x1c, 0x14, 0x0b, 0x04, 0x17, 0x08, 0xe1, 0xed,
  0xe6, 0xcb, 0xf4, 0x12, 0xf9, 0xf6, 0x22, 0x2c, 0xf7, 0xcf, 0xed, 0xc9, 0xc3, 0xe1, 0x17, 0x07,
  0xf7, 0xe2, 0xd5, 0xe4, 0xcc, 0xbb, 0xb7, 0xba, 0xda, 0xf0, 0x18, 0x19, 0x20, 0xfe, 0x26, 0x38,
  0x19, 0xdc, 0xe7, 0xdd, 0x07, 0x23, 0x2f, 0x43, 0x38, 0x41, 0x23, 0x12, 0x1b, 0x16, 0xeb, 0xff,
  0xea, 0x13, 0xfc, 0xec, 0xf3, 0xcb, 0xd8, 0xc9, 0xb9, 0xc7, 0xab, 0xcf, 0xbc, 0xba, 0xe7, 0xe9,
  0xe4, 0xf3, 0xfc, 0x18, 0x36, 0x24, 0xfe, 0x13, 0x2a, 0xf9, 0xd3, 0xf9, 0xd7, 0xe5, 0xf6, 0xe9,
  0x09, 0x12, 0x1b, 0x12, 0x24, 0x23, 0x03, 0xde, 0xe9, 0xd6, 0xc3, 0xd9, 0xe2, 0x05, 0xdc, 0xc8,
  0xd8, 0x11, 0x2a, 0x2e, 0x21, 0xf3, 0xf2, 0x18, 0x0f, 0x1f, 0x03, 0x19, 0xe1, 0xe7, 0xcf, 0xdf,
  0xd3, 0xd6, 0xcb, 0xf6, 0xec, 0x00, 0x06, 0x25, 0x24, 0x25, 0x1b, 0x12, 0x09, 0x1c, 0x1d, 0xf9,
  0x15, 0xff, 0x0b, 0x03, 0x15, 0x14, 0x25, 0x1c, 0x12, 0x0a, 0xf9, 0x14, 0x0d, 0xe8, 0xd6, 0xdb,
  0xff, 0x1a, 0x21, 0x26, 0x22, 0x18, 0x0d, 0xf1, 0xb5, 0xc0, 0xbf, 0xb4, 0xf2, 0xf5, 0xee, 0xaa,
  0xc0, 0xf3, 0x1c, 0x30, 0x05, 0xd4, 0xb8, 0x05, 0x3a, 0x42, 0x27, 0x03, 0x07, 0xfb, 0xe1, 0xdd,
  0xce, 0xca, 0xe4, 0xf3, 0xee, 0xea, 0xfb, 0xf9, 0x2b, 0x03, 0x04, 0xef, 0xf6, 0xfa, 0xd5, 0xe5,
  0xeb, 0xf2, 0x2a, 0xf9, 0x28, 0x16, 0x38, 0x1b, 0x1c, 0x1b, 0x21, 0x39, 0x2c, 0x0f, 0xbb, 0xc0,
  0xd8, 0xbe, 0xea, 0xa3, 0x8c, 0x3e, 0xf6, 0x4f, 0xaf, 0xbe, 0x37, 0xc0, 0x1c, 0x3e, 0x49, 0x4f,
  0xef, 0x3e, 0x1c, 0x1d, 0x1f, 0xbf, 0xb8, 0x76, 0xdb, 0x3e, 0x3b, 0x11, 0xcc, 0x3e, 0x4a, 0x62,
  0x60, 0x7f, 0xaa, 0x53, 0xb2, 0xb0, 0x7f, 0x96, 0xef, 0xbe,
};


constexpr DemoCase kDemoCases[] = {
  {"228:160", 0, -6.61995602e+00f, {
    -3.28070968e-01f, -2.81197876e-01f, -2.42136955e-01f, -2.83801943e-01f, -3.28070968e-01f, -3.07238489e-01f, -3.51507515e-01f, -2.91614115e-01f,
    -2.65573502e-01f, -2.65573502e-01f, -2.03076050e-01f, -2.42136955e-01f, -1.40578583e-01f, -2.86039785e-02f, -1.22350164e-01f, -2.52553195e-01f,
    -3.77548128e-01f, -2.49949142e-01f, 3.64975370e-02f, 1.64096519e-01f, 9.19274092e-01f, 1.00000000e+00f, 4.81791914e-01f, 6.77462667e-02f,
    -4.16242816e-02f, -4.16242816e-02f, 1.82691142e-02f, -6.50608316e-02f, -7.28730112e-02f, -4.16242816e-02f, -3.90202217e-02f, 4.06884501e-05f,
    5.99340834e-02f, 4.06884501e-05f, 7.55584463e-02f, 1.12015299e-01f, 1.19827479e-01f, 1.43264025e-01f, 1.48472145e-01f, 1.58888385e-01f,
    2.63050824e-01f, 2.29198024e-01f, 2.18781784e-01f, 3.15132022e-01f, 2.96903610e-01f, 2.94299543e-01f, 3.07319850e-01f, 2.76071131e-01f,
    2.70862997e-01f, 2.99507678e-01f, 1.82324931e-01f, 1.30243719e-01f, 1.04203120e-01f, -3.38121019e-02f, -4.94364649e-02f, -7.54770711e-02f,
    -1.58807009e-01f, -1.69223264e-01f, -1.48390770e-01f, -2.36928836e-01f, -2.10888222e-01f, -2.55157262e-01f, -2.39532903e-01f, -2.52553195e-01f,
  }},
  {"228:6299", 1, 4.46503210e+00f, {
    -1.84896216e-02f, -2.05416493e-02f, -1.84896216e-02f, -1.02815125e-02f, -1.91736314e-02f, -1.64375957e-02f, -1.02815125e-02f, -1.64375957e-02f,
    1.09227709e-02f, 5.45069808e-03f, 6.62633858e-04f, 1.22907897e-02f, -8.22948478e-03f, 4.76668868e-03f, 1.07368059e-01f, 2.51009971e-01f,
    4.03544009e-01f, 6.08062744e-01f, 7.46916592e-01f, 8.47465932e-01f, 9.76743698e-01f, 1.00000000e+00f, 8.46781969e-01f, 4.82205063e-01f,
    1.21048242e-01f, -5.81621528e-02f, -1.58711493e-01f, -1.88807905e-01f, -1.79915786e-01f, -1.75811723e-01f, -1.74443707e-01f, -1.75811723e-01f,
    -1.77863747e-01f, -1.82651818e-01f, -1.73075691e-01f, -1.92227945e-01f, -1.89491913e-01f, -2.09328175e-01f, -2.27112412e-01f, -2.31900483e-01f,
    -2.55840808e-01f, -2.54472792e-01f, -2.38740563e-01f, -2.44896650e-01f, -2.44896650e-01f, -2.46948674e-01f, -2.40792602e-01f, -2.16168270e-01f,
    -1.95647985e-01f, -1.97016016e-01f, -1.80599794e-01f, -1.54607445e-01f, -1.29983112e-01f, -1.21775001e-01f, -1.21090993e-01f, -1.05358787e-01f,
    -6.84222877e-02f, -7.18423352e-02f, -6.97903112e-02f, -4.10619229e-02f, -3.90098952e-02f, -4.17459346e-02f, -4.92700338e-02f, -6.15822002e-02f,
  }},
};

#include <Arduino.h>

constexpr int kNormalLed = 18;
constexpr int kPvcLed = 19;

void setup() {
  Serial.begin(115200);
  pinMode(kNormalLed, OUTPUT);
  pinMode(kPvcLed, OUTPUT);
  Serial.printf("MODEL bytes=%u sha256=%s\n", unsigned(sizeof(kModel)), kModelSha256);
}

void loop() {
  static size_t index = 0;
  const DemoCase &beat = kDemoCases[index];
  const float z = predict(kModel, sizeof(kModel), beat.samples);
  const bool valid = isfinite(z);
  const bool pvc = z >= 0;
  digitalWrite(kNormalLed, valid && !pvc ? HIGH : LOW);
  digitalWrite(kPvcLed, valid && pvc ? HIGH : LOW);
  Serial.printf("BEAT %s annotation=%c esp32=%.8f python=%.8f predicted=%c parity=%s\n",
                beat.id, beat.annotation ? 'V' : 'N', double(z), double(beat.pythonLogit),
                valid ? (pvc ? 'V' : 'N') : '?', matchesPython(z, beat.pythonLogit) ? "PASS" : "FAIL");
  index = (index + 1) % (sizeof(kDemoCases) / sizeof(kDemoCases[0]));
  delay(2000);
}
